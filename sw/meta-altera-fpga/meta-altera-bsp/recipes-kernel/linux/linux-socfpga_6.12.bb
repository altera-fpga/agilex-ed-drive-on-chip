LINUX_VERSION = "6.12.11"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "2f0b0270dbabe9acc602bd269b4f85253e8a6e6d"

include linux-socfpga.inc
