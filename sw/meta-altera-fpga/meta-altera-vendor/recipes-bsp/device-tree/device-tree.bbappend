FILESEXTRAPATHS:append := ":${THISDIR}/arrow"
FILESEXTRAPATHS:append := ":${THISDIR}/macnica"

# Macnica
SRC_URI:agilex5_sulfur = "file://socfpga_agilex5_sulfur.dts"

# Arrow
SRC_URI:agilex5_axe5_eagle = "file://socfpga_agilex5_axe5_eagle.dts"

