FILESEXTRAPATHS:append := ":${THISDIR}/files"

SRC_URI:append = " file://uio.cfg"

